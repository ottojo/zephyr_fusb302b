## drivers/usb_c/vbus/Kconfig
```kconfig
if USBC_VBUS_DRIVER

rsource "Kconfig.usbc_vbus_fusb302b"

endif # USBC_VBUS_DRIVER
```
